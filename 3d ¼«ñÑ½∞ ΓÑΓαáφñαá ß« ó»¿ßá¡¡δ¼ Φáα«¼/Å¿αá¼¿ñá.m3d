# KOMPAS-3D part "Пирамида" (Å¿αá¼¿ñá.m3d)
File: written by KOMPAS-3D 18.0.

Product:
- Part/product: Пирамида

Model tree:
1. Операция без истории:1